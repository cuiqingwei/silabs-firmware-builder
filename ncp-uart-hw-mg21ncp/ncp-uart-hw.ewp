# IAR project ncp-uart-hw.ewp, settings and files
configuration Default (ARM, debug)
  General.OGChipSelectEditMenu: EFR32MG21A020F512IM32 SiliconLaboratories EFR32MG21A020F512IM32
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 6
  ICCARM.CCDefines: EMBER_CUSTOM_MAC_FILTER_TABLE_SIZE=15; EFR32MG21A020F512IM32=1; SL_APP_PROPERTIES=1; SL_COMPONENT_CATALOG_PRESENT=1; SEGGER_RTT_ALIGNMENT=1024; EMBER_AF_API_BOOTLOADER_INTERFACE=1; CORTEXM3=1; CORTEXM3_EFM32_MICRO=1; CORTEXM3_EFR32=1; PHY_RAIL=1; PLATFORM_HEADER="platform-header.h"; SL_LEGACY_HAL_ENABLE_WATCHDOG=1; MBEDTLS_CONFIG_FILE=<sl_mbedtls_config.h>; MBEDTLS_PSA_CRYPTO_CONFIG_FILE=<psa_crypto_config.h>; SL_RAIL_LIB_MULTIPROTOCOL_SUPPORT=0; SL_RAIL_UTIL_PA_CONFIG_HEADER=<sl_rail_util_pa_config.h>; RTT_USE_ASM=0; CUSTOM_TOKEN_HEADER="sl_token_manager_af_token_header.h"; USE_NVM3=1; UC_BUILD=1; EMBER_AF_NCP=1; EMBER_SERIAL1_RTSCTS=1; EZSP_UART=1; NO_USB=1; EMBER_MULTI_NETWORK_STRIPPED=1; SL_ZIGBEE_PHY_SELECT_STACK_SUPPORT=1
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.IExtraOptions: --cmse
  ICCARM.CCIncludePath2: $FILE_DIR$; config; autogen; ..\..\gecko_sdk\platform\Device\SiliconLabs\EFR32MG21\Include; ..\..\gecko_sdk\platform\common\inc; ..\..\gecko_sdk\platform\bootloader; ..\..\gecko_sdk\platform\bootloader\api; ..\..\gecko_sdk\platform\CMSIS\Core\Include; ..\..\gecko_sdk\platform\driver\debug\inc; ..\..\gecko_sdk\platform\service\device_init\inc; ..\..\gecko_sdk\platform\emdrv\dmadrv\inc; ..\..\gecko_sdk\platform\emdrv\common\inc; ..\..\gecko_sdk\platform\emlib\inc; ..\..\gecko_sdk\platform\service\hfxo_manager\inc; ..\..\gecko_sdk\platform\service\iostream\inc; ..\..\gecko_sdk\platform\service\legacy_hal\inc; ..\..\gecko_sdk\platform\service\legacy_common_ash\inc; ..\..\gecko_sdk\platform\service\legacy_hal_wdog\inc; ..\..\gecko_sdk\platform\service\legacy_ncp_ash\inc; ..\..\gecko_sdk\platform\service\legacy_printf\inc; ..\..\gecko_sdk\platform\security\sl_component\sl_mbedtls_support\config; ..\..\gecko_sdk\platform\security\sl_component\sl_mbedtls_support\inc; ..\..\gecko_sdk\util\third_party\mbedtls\include; ..\..\gecko_sdk\util\third_party\mbedtls\library; ..\..\gecko_sdk\platform\emdrv\nvm3\inc; ..\..\gecko_sdk\platform\service\power_manager\inc; ..\..\gecko_sdk\util\third_party\printf; ..\..\gecko_sdk\util\third_party\printf\inc; ..\..\gecko_sdk\platform\security\sl_component\sl_psa_driver\inc; ..\..\gecko_sdk\platform\security\sl_component\sl_psa_driver\inc\public; ..\..\gecko_sdk\platform\radio\rail_lib\common; ..\..\gecko_sdk\platform\radio\rail_lib\protocol\ble; ..\..\gecko_sdk\platform\radio\rail_lib\protocol\ieee802154; ..\..\gecko_sdk\platform\radio\rail_lib\protocol\zwave; ..\..\gecko_sdk\platform\radio\rail_lib\chip\efr32\efr32xg2x; ..\..\gecko_sdk\platform\radio\rail_lib\plugin\rail_util_ieee802154; ..\..\gecko_sdk\platform\radio\rail_lib\plugin\pa-conversions; ..\..\gecko_sdk\platform\radio\rail_lib\plugin\pa-conversions\efr32xg21; ..\..\gecko_sdk\platform\radio\rail_lib\plugin\rail_util_pti; ..\..\gecko_sdk\platform\radio\rail_lib\plugin\rail_util_rf_path; ..\..\gecko_sdk\platform\security\sl_component\se_manager\inc; ..\..\gecko_sdk\platform\security\sl_component\se_manager\src; ..\..\gecko_sdk\util\third_party\segger\systemview\SEGGER; ..\..\gecko_sdk\util\silicon_labs\silabs_core\memory_manager; ..\..\gecko_sdk\platform\common\toolchain\inc; ..\..\gecko_sdk\platform\service\system\inc; ..\..\gecko_sdk\platform\service\sleeptimer\inc; ..\..\gecko_sdk\platform\service\token_manager\inc; ..\..\gecko_sdk\protocol\zigbee\app\framework\common; ..\..\gecko_sdk\protocol\zigbee\stack\include; ..\..\gecko_sdk\protocol\zigbee\app\em260; ..\..\gecko_sdk\protocol\zigbee\stack\platform\micro; ..\..\gecko_sdk\protocol\zigbee\stack\framework; ..\..\gecko_sdk\protocol\zigbee\app\framework\plugin\debug-print; ..\..\gecko_sdk\protocol\zigbee\stack\gp; ..\..\gecko_sdk\protocol\zigbee\app\xncp; ..\..\gecko_sdk\protocol\zigbee\app\util\ezsp; ..\..\gecko_sdk\protocol\zigbee\app\framework\util; ..\..\gecko_sdk\protocol\zigbee\app\util\security; ..\..\gecko_sdk\protocol\zigbee\stack\zigbee; ..\..\gecko_sdk\protocol\zigbee\stack\security; ..\..\gecko_sdk\platform\radio\rail_lib\plugin; ..\..\gecko_sdk\protocol\zigbee; ..\..\gecko_sdk\protocol\zigbee\stack; ..\..\gecko_sdk\platform\radio\mac\rail_mux; ..\..\gecko_sdk\platform\radio\mac; ..\..\gecko_sdk\util\silicon_labs\silabs_core; ..\..\gecko_sdk\protocol\zigbee\stack\core; ..\..\gecko_sdk\protocol\zigbee\stack\mac; ..\..\gecko_sdk\protocol\zigbee\stack\zll
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 2
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: ncp-uart-hw.s37
  ILINK.IlinkOutputFile: ncp-uart-hw.out
  ILINK.IlinkIcfFile: autogen\linkerfile_base.icf
  group (top)
    ./: ncp-uart-hw.ipcf
